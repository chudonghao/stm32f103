# Keil uVision project study.uvprojx, settings and files
target study (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: study +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,ARM_MATH_CM3,STM32F10X_HD
  c include: ..\study
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group source
    ./: usart1.cpp usart1.h led.h led.cpp main.cpp encoder.cpp encoder.h step_motor.h step_motor.cpp mpu9250.cpp mpu9250.h
software components: CMSIS:CORE 5.0.1, CMSIS:DSP 1.5.1, CMSIS:RTOS:Keil RTX5 5.1.0, CMSIS:RTOS2:Keil RTX5 5.1.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
