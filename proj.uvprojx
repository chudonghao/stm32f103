# Keil uVision project proj.uvprojx, settings and files
target proj (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: P3 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ./;.\third_party\FreeRTOSv9.0.0\FreeRTOS\Source\include;.\third_party\FreeRTOSv9.0.0\FreeRTOS\Source\portable\RVDS\ARM_CM3;.\third_party\stm32f1_warship_v3\camera_test\SYSTEM\sys;.\third_party\stm32f1_warship_v3\camera_test\HARDWARE\LCD;.\third_party\stm32f1_warship_v3\camera_test\SYSTEM\usart;.\third_party\stm32f1_warship_v3\camera_test\SYSTEM\delay;.\third_party\stm32f1_warship_v3\camera_test\HARDWARE\TIMER;.\third_party\stm32f1_warship_v3\camera_test\HARDWARE\EXTI;.\third_party\stm32f1_warship_v3\camera_test\HARDWARE\OV7670;.\third_party\stm32f1_warship_v3\camera_test\HARDWARE\LED;.\third_party\stm32f1_warship_v3\camera_test\HARDWARE\KEY;.\third_party\stm32f1_warship_v3\camera_test\HARDWARE\BEEP;.\third_party\glm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ./: main.cpp
  group freertos_core
    ./third_party/FreeRTOSv9.0.0/FreeRTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group freertos_portable
    ./third_party/FreeRTOSv9.0.0/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ./third_party/FreeRTOSv9.0.0/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ./: FreeRTOSConfig.h
  group openedv_sys
    ./third_party/stm32f1_warship_v3/camera_test/SYSTEM/sys/: sys.c
    ./third_party/stm32f1_warship_v3/camera_test/SYSTEM/delay/: delay.c
    ./third_party/stm32f1_warship_v3/camera_test/SYSTEM/usart/: usart.c
  group openedv_hardware
    ./third_party/stm32f1_warship_v3/camera_test/HARDWARE/OV7670/: ov7670.c sccb.c
    ./third_party/stm32f1_warship_v3/camera_test/HARDWARE/LCD/: lcd.c
    ./third_party/stm32f1_warship_v3/camera_test/HARDWARE/EXTI/: exti.c
software components: CMSIS:CORE 5.0.1, CMSIS:DSP 1.5.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:FSMC 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
